# Keil uVision project simpleBMS.uvproj, settings and files
target simpleBMS (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: simpleBMS +hex
  AfterMake: ..\obj\hex2bin.exe ..\obj\simpleBMS.hex
  c flags: Optimize=8 SizeSpeed=1
  group hal
    ../../mcu/: hal_clk.c hal_core.c hal_gpio.c hal_uart.c hal_wtd.c hal_adc.c hal_timer.c
  group common
    ../../common/: Conf_tny.A51 ring_buffer.c msg.c
  group user
    ../../user/: button.c led.c bms.c system.c console.c
